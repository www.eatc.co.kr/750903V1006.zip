# Autodesk Inventor part: 6각 구멍붙이 볼트 M4x10
Saved by Autodesk Inventor 2014 (Build 180170000, 170)
## iProperties
Created: 2025-09
Part Number: 6각 구멍붙이 볼트 M4x10
Material: 일반
Document SubType Name: Modeling
Designer: dg
Density: 1 g/cm^3
Appearance: 기본값
Author: dg
Author: jhkim
Description: 6각머리 태핑 나사
Creation Date: 2025-09-02
Sending System: Autodesk Inventor 2026
Preprocessor: ST-DEVELOPER v20.1
## Design history (mm, degrees)
node "6각 구멍붙이 볼트 M4x101"
body "Solid1"
node "기준1"
